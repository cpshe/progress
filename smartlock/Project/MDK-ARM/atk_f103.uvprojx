# Keil uVision project atk_f103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\BSP;..\..\Drivers;..\..\User;..\..\Middlewares;..\..\ONENET\MQTT;..\..\ONENET\device\inc;..\..\ONENET\onenet\inc;..\..\ONENET\CJSON
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_hal_spi.c stm32f1xx_hal_exti.c stm32f1xx_hal_sram.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_ll_sdmmc.c
  group Drive/BSP
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/EXTI/: exti.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/KEYBORD/: keybord.c
    ../../Drivers/BSP/RC522/: rc522.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/PWMTIMER/: pwmtimer.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/TOUCH/: ctiic.c touch.c
    ../../Drivers/BSP/SPI2/: spi2.c
    ../../Drivers/BSP/NORFLASH/: norflash.c
    ../../Drivers/BSP/SERVO/: servo.c
    ../../Drivers/BSP/USART2/: usart2.c
    ../../Drivers/BSP/AS608/: as608.c
    ../../Drivers/BSP/PASSWORD/: password.c
    ../../Drivers/BSP/HC05/: hc05.c
    ../../Drivers/BSP/TIMER7/: timer7.c
    ../../Drivers/BSP/USART3/: usart3.c
    ../../Drivers/BSP/TIM2/: time2.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/OV7670/: sccb.c ov7670.c
    ../../Drivers/BSP/SDIO/: sdio_sdcard.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffunicode.c ffsystem.c
  group Middlewares/TEXT
    ../../Middlewares/TEXT/: fonts.c text.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/PICTURE
    ../../Middlewares/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group ONENET
    ../../ONENET/CJSON/: cJSON.c
    ../../ONENET/device/src/: esp8266.c
    ../../ONENET/MQTT/: MqttKit.c
    ../../ONENET/onenet/src/: base64.c hmac_sha1.c onenet.c
